# Keil uVision project MySTM32.uvprojx, settings and files
target MySTM32 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MySTM32 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\System\inc;.\Library\inc;.\Start\inc;.\App\inc;.\Hardware\inc;.\Middleware\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\MySTM32.sct
  group App
    ./App/src/: dinosaur.c AppManager.c AppIcon.c YangSystem.c ServoContrl.c
  group Hardware
    ./Hardware/src/: oled.c serial.c key.c encoder.c mpu6050.c pwm.c Servo.c
  group Middleware
    ./Middleware/src/: interrupt.c module.c gpio.c i2c.c
  group Library
    ./Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_it.c
  group System
    ./System/src/: Delay.c log.c clock.c font.c
  group User
    ./User/: main.c
  group Start
    ./Start/src/: startup_stm32f10x_md.s system_stm32f10x.c
